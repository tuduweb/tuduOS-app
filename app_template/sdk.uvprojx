# Keil uVision project sdk.uvprojx, settings and files
target SDK (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: sdk
  AfterMake: fromelf --bin !L --output app.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --lower_rwpi --lower_ropi
  c include: ./../sdk/iinclude;./../sdk/armcc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\sdk\link.sct
  group S
    ../sdk/: startup.s
  group C
    ../sdk/: syscall.s
    ../sdk/armcc/: retarget.c memory.c tlsf.c
  group App
    ./: main.c
